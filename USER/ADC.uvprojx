# Keil uVision project ADC.uvprojx, settings and files
target ADC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\ADC;..\FWLIB\inc;..\HARDWARE\MQ_Sensor;..\HARDWARE\EXTI;..\HARDWARE\SC_HR501;..\HARDWARE\DHT11;..\HARDWARE\Motor;..\HARDWARE\Rain_detect;..\HARDWARE\OLED;..\ATK-ESP8266;..\HARDWARE\TIMER;..\HARDWARE\USART3;..\ATK-ESP8266;..\HARDWARE\MOTO;..\HARDWARE\PWM;..\HARDWARE\OLED_IIC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MQ_Sensor/: mq_sensor.c
    ../HARDWARE/SC_HR501/: hc_sr501.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/Rain_detect/: rain_detect.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTO/: encoder.c
    ../HARDWARE/OLED_IIC/: oled.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_exti.c
  group README
    ../: readme.txt
  group ATK-ESP8266
    ../ATK-ESP8266/: common.c
